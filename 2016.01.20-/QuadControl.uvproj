# Keil uVision project QuadControl.uvproj, settings and files
target quadrotor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: QuadControl
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\User\Algorithm\inc;.\User\BSP\inc;.\User\CMSIS\CM3\Core_Support;.\User\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\User\STM32F10x_StdPeriph_Driver\inc;.\User\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/User/src/: MAIN.c stm32f10x_it.c global.c
    ./: ReadMe.txt
  group StartUp
    ./User/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./User/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ./User/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ./User/BSP/src/: adc.c delay.c eeprom.c flash.c GPS.c HMC5883L.c key.c led.c Moto.c MPU6050.c MS5611.c Nrf24l01.c Spi.c sys.c Tim_pwm_in.c timer.c usart.c filter.c ADNS3080.c matrix.c
  group Algorithm
    ./User/Algorithm/src/: DATA_Transfer.c IMU.c PID.c Altitude.c
